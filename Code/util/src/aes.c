/*
 * aes.c
 *
 *  Created on: 08-10-2013
 *      Author: Tomek
 */

#include <util/aes.h>
#include <util/string.h>

/* exponential in galois field 2^8 */
static const uint8_t rcon[256] = {
	0x8d, 0x01, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40,
	0x80, 0x1b, 0x36, 0x6c, 0xd8, 0xab, 0x4d, 0x9a,
	0x2f, 0x5e, 0xbc, 0x63, 0xc6, 0x97, 0x35, 0x6a,
	0xd4, 0xb3, 0x7d, 0xfa, 0xef, 0xc5, 0x91, 0x39,
	0x72, 0xe4, 0xd3, 0xbd, 0x61, 0xc2, 0x9f, 0x25,
	0x4a, 0x94, 0x33, 0x66, 0xcc, 0x83, 0x1d, 0x3a,
	0x74, 0xe8, 0xcb, 0x8d, 0x01, 0x02, 0x04, 0x08,
	0x10, 0x20, 0x40, 0x80, 0x1b, 0x36, 0x6c, 0xd8,
	0xab, 0x4d, 0x9a, 0x2f, 0x5e, 0xbc, 0x63, 0xc6,
	0x97, 0x35, 0x6a, 0xd4, 0xb3, 0x7d, 0xfa, 0xef,
	0xc5, 0x91, 0x39, 0x72, 0xe4, 0xd3, 0xbd, 0x61,
	0xc2, 0x9f, 0x25, 0x4a, 0x94, 0x33, 0x66, 0xcc,
	0x83, 0x1d, 0x3a, 0x74, 0xe8, 0xcb, 0x8d, 0x01,
	0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x80, 0x1b,
	0x36, 0x6c, 0xd8, 0xab, 0x4d, 0x9a, 0x2f, 0x5e,
	0xbc, 0x63, 0xc6, 0x97, 0x35, 0x6a, 0xd4, 0xb3,
	0x7d, 0xfa, 0xef, 0xc5, 0x91, 0x39, 0x72, 0xe4,
	0xd3, 0xbd, 0x61, 0xc2, 0x9f, 0x25, 0x4a, 0x94,
	0x33, 0x66, 0xcc, 0x83, 0x1d, 0x3a, 0x74, 0xe8,
	0xcb, 0x8d, 0x01, 0x02, 0x04, 0x08, 0x10, 0x20,
	0x40, 0x80, 0x1b, 0x36, 0x6c, 0xd8, 0xab, 0x4d,
	0x9a, 0x2f, 0x5e, 0xbc, 0x63, 0xc6, 0x97, 0x35,
	0x6a, 0xd4, 0xb3, 0x7d, 0xfa, 0xef, 0xc5, 0x91,
	0x39, 0x72, 0xe4, 0xd3, 0xbd, 0x61, 0xc2, 0x9f,
	0x25, 0x4a, 0x94, 0x33, 0x66, 0xcc, 0x83, 0x1d,
	0x3a, 0x74, 0xe8, 0xcb, 0x8d, 0x01, 0x02, 0x04,
	0x08, 0x10, 0x20, 0x40, 0x80, 0x1b, 0x36, 0x6c,
	0xd8, 0xab, 0x4d, 0x9a, 0x2f, 0x5e, 0xbc, 0x63,
	0xc6, 0x97, 0x35, 0x6a, 0xd4, 0xb3, 0x7d, 0xfa,
	0xef, 0xc5, 0x91, 0x39, 0x72, 0xe4, 0xd3, 0xbd,
	0x61, 0xc2, 0x9f, 0x25, 0x4a, 0x94, 0x33, 0x66,
	0xcc, 0x83, 0x1d, 0x3a, 0x74, 0xe8, 0xcb, 0x8d
};

/* s-box */
static const uint8_t sbox[256] = {
	0x63, 0x7C, 0x77, 0x7B, 0xF2, 0x6B, 0x6F, 0xC5,
	0x30, 0x01, 0x67, 0x2B, 0xFE, 0xD7, 0xAB, 0x76,
	0xCA, 0x82, 0xC9, 0x7D, 0xFA, 0x59, 0x47, 0xF0,
	0xAD, 0xD4, 0xA2, 0xAF, 0x9C, 0xA4, 0x72, 0xC0,
	0xB7, 0xFD, 0x93, 0x26, 0x36, 0x3F, 0xF7, 0xCC,
	0x34, 0xA5, 0xE5, 0xF1, 0x71, 0xD8, 0x31, 0x15,
	0x04, 0xC7, 0x23, 0xC3, 0x18, 0x96, 0x05, 0x9A,
	0x07, 0x12, 0x80, 0xE2, 0xEB, 0x27, 0xB2, 0x75,
	0x09, 0x83, 0x2C, 0x1A, 0x1B, 0x6E, 0x5A, 0xA0,
	0x52, 0x3B, 0xD6, 0xB3, 0x29, 0xE3, 0x2F, 0x84,
	0x53, 0xD1, 0x00, 0xED, 0x20, 0xFC, 0xB1, 0x5B,
	0x6A, 0xCB, 0xBE, 0x39, 0x4A, 0x4C, 0x58, 0xCF,
	0xD0, 0xEF, 0xAA, 0xFB, 0x43, 0x4D, 0x33, 0x85,
	0x45, 0xF9, 0x02, 0x7F, 0x50, 0x3C, 0x9F, 0xA8,
	0x51, 0xA3, 0x40, 0x8F, 0x92, 0x9D, 0x38, 0xF5,
	0xBC, 0xB6, 0xDA, 0x21, 0x10, 0xFF, 0xF3, 0xD2,
	0xCD, 0x0C, 0x13, 0xEC, 0x5F, 0x97, 0x44, 0x17,
	0xC4, 0xA7, 0x7E, 0x3D, 0x64, 0x5D, 0x19, 0x73,
	0x60, 0x81, 0x4F, 0xDC, 0x22, 0x2A, 0x90, 0x88,
	0x46, 0xEE, 0xB8, 0x14, 0xDE, 0x5E, 0x0B, 0xDB,
	0xE0, 0x32, 0x3A, 0x0A, 0x49, 0x06, 0x24, 0x5C,
	0xC2, 0xD3, 0xAC, 0x62, 0x91, 0x95, 0xE4, 0x79,
	0xE7, 0xC8, 0x37, 0x6D, 0x8D, 0xD5, 0x4E, 0xA9,
	0x6C, 0x56, 0xF4, 0xEA, 0x65, 0x7A, 0xAE, 0x08,
	0xBA, 0x78, 0x25, 0x2E, 0x1C, 0xA6, 0xB4, 0xC6,
	0xE8, 0xDD, 0x74, 0x1F, 0x4B, 0xBD, 0x8B, 0x8A,
	0x70, 0x3E, 0xB5, 0x66, 0x48, 0x03, 0xF6, 0x0E,
	0x61, 0x35, 0x57, 0xB9, 0x86, 0xC1, 0x1D, 0x9E,
	0xE1, 0xF8, 0x98, 0x11, 0x69, 0xD9, 0x8E, 0x94,
	0x9B, 0x1E, 0x87, 0xE9, 0xCE, 0x55, 0x28, 0xDF,
	0x8C, 0xA1, 0x89, 0x0D, 0xBF, 0xE6, 0x42, 0x68,
	0x41, 0x99, 0x2D, 0x0F, 0xB0, 0x54, 0xBB, 0x16
};

/* rotation function */
static void AES_Rotate(uint8_t *in)
{
	uint8_t t = in[3];
	/* rotate */
	in[3] = in[2];
	in[2] = in[1];
	in[1] = in[0];
	in[0] = t;
}

/* multiply by two */
static uint8_t AES_GaloisMul2(uint8_t val)
{
	return val & 0x80 ? (val << 1) ^ 0x1b : (val << 1);
}

/* key schedule core */
static void AES_KeyScheduleCore(uint8_t *in, uint8_t iter)
{
	/* rotate */
	AES_Rotate(in);
	/* apply sbox operation on all four bytes */
	in[0] = sbox[in[0]];
	in[1] = sbox[in[1]];
	in[2] = sbox[in[2]];
	in[3] = sbox[in[3]];
	/* do the rcon operation on the first byte */
	in[3] ^= rcon[iter];
}

/* generate expanded key */
static void AES_KeySchedule(uint8_t *key, uint8_t *ekey)
{
	int b = 0, i, j;

	/* the first 16 bytes of expanded key are simply the key */
	memcpy(ekey + 0, key, 16);
	/* iteration value (rcon) is set to one */
	i = 1; b = 16;

	/* Until we have b bytes of expanded key, we do the following to generate n
	 * more bytes of expanded key */
	while (b != 176) {
		/* We do the following to create 4 bytes of expanded key */
		/* We create a 4-byte temporary variable  */
		uint8_t t[4];
		/* We assign the value of the previous four bytes in the expanded key
		 * to t */
		t[0] = ekey[(i - 1) * 16 + 0];
		t[1] = ekey[(i - 1) * 16 + 1];
		t[2] = ekey[(i - 1) * 16 + 2];
		t[3] = ekey[(i - 1) * 16 + 3];
		/* We perform the key schedule core (see above) on t, with i as the rcon
		 * iteration value */
		AES_KeyScheduleCore(t, i);
		/* We exclusive-OR t with the four-byte block n bytes before the new
		 * expanded key. This becomes the next 4 bytes in the expanded key */
		ekey[i * 16 + 12] = t[0] ^ ekey[(i - 1) * 16 + 12];
		ekey[i * 16 + 13] = t[1] ^ ekey[(i - 1) * 16 + 13];
		ekey[i * 16 + 14] = t[2] ^ ekey[(i - 1) * 16 + 14];
		ekey[i * 16 + 15] = t[3] ^ ekey[(i - 1) * 16 + 15];

		/* We then do the following three times to create the next twelve bytes
		 * of expanded key: */
		for (j = 2; j >= 0; j--) {
			/* We assign the value of the previous 4 bytes in the expanded key
			 * to t */
			t[0] = ekey[(i - 1) * 16 + j * 4 + 0];
			t[1] = ekey[(i - 1) * 16 + j * 4 + 1];
			t[2] = ekey[(i - 1) * 16 + j * 4 + 2];
			t[3] = ekey[(i - 1) * 16 + j * 4 + 3];
			/* We exclusive-OR t with the four-byte block n bytes before the new
			 * expanded key. This becomes the next 4 bytes in the expanded key
			 * */
			ekey[i * 16 + j * 4 + 0] = t[0] ^ ekey[i * 16 + (j + 1) * 4 + 0];
			ekey[i * 16 + j * 4 + 1] = t[1] ^ ekey[i * 16 + (j + 1) * 4 + 1];
			ekey[i * 16 + j * 4 + 2] = t[2] ^ ekey[i * 16 + (j + 1) * 4 + 2];
			ekey[i * 16 + j * 4 + 3] = t[3] ^ ekey[i * 16 + (j + 1) * 4 + 3];
		}
		/* we have generated 16 bytes */
		b += 16;
		/* increment i */
		i++;
	}
}

/* add round key step */
static void AES_AddRoundKey(uint8_t *key, uint8_t *state)
{
	int i;
	/* add round key */
	for (i = 0; i < 16; i++) {
		state[i] ^= key[i];
	}
}

/* bytes substitution */
static void AES_SubBytes(uint8_t *state)
{
	int i;
	/* add round key */
	for (i = 0; i < 16; i++) {
		state[i] = sbox[state[i]];
	}
}

/* shift rows */
static void AES_ShiftRows(uint8_t *state)
{
	uint8_t t[2];

	/* first four bytes are left uncahnged */

	/* 2nd row */
	t[0] = state[14];
    state[14] = state[10];
    state[10] = state[6];
    state[6] = state[2];
    state[2] = t[0];

	/* 3rd row */
	t[0] = state[13];
	t[1] = state[9];
	state[13] = state[5];
	state[9] = state[1];
	state[5] = t[0];
	state[1] = t[1];

	/* 4rd row */
	t[0] = state[0];
	state[0] = state[4];
	state[4] = state[8];
	state[8] = state[12];
	state[12] = t[0];

}

/* mix colums */
static void AES_MixColums(uint8_t *state)
{
	int i;
	uint8_t b[4], a[4], t[4];

	/* for every column */
	for (i = 0; i < 4; i++) {
		/* prepare mul by two */
		b[0] = AES_GaloisMul2(state[i * 4 + 0]);
		b[1] = AES_GaloisMul2(state[i * 4 + 1]);
		b[2] = AES_GaloisMul2(state[i * 4 + 2]);
		b[3] = AES_GaloisMul2(state[i * 4 + 3]);

		/* prepare mul by one */
		a[0] = state[i * 4 + 0];
		a[1] = state[i * 4 + 1];
		a[2] = state[i * 4 + 2];
		a[3] = state[i * 4 + 3];

		/* multiply by matrix */
		t[3] = a[0] ^ a[1] ^ b[2] ^ a[2] ^ b[3];
		t[2] = a[0] ^ b[1] ^ a[1] ^ b[2] ^ a[3];
		t[1] = b[0] ^ a[0] ^ b[1] ^ a[2] ^ a[3];
		t[0] = b[0] ^ a[1] ^ a[2] ^ b[3] ^ a[3];

		/* write back */
		state[i * 4 + 0] = t[0];
		state[i * 4 + 1] = t[1];
		state[i * 4 + 2] = t[2];
		state[i * 4 + 3] = t[3];
	}
}

/* perform encryption, all is kept in little endian here */
void AES_Encrypt(uint8_t *key, uint8_t *state)
{
	/* expanded key */
	uint8_t ex_key[176];
	uint8_t round;

	/* prepare key */
	AES_KeySchedule(key, ex_key);

	/* initial round  - add key */
	AES_AddRoundKey(ex_key, state);

	/* 9 main rounds */
	for (round = 1; round <= 9; round++) {
		/* sub bytes */
		AES_SubBytes(state);
		/* shift rows */
		AES_ShiftRows(state);
		/* mix columns */
		AES_MixColums(state);

		/* add round key */
		AES_AddRoundKey(ex_key + round * 16, state);
	}

	/* last round */
	AES_SubBytes(state);
	/* shift rows */
	AES_ShiftRows(state);
	/* add round key */
	AES_AddRoundKey(ex_key + 160, state);
}
